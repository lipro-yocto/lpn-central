#
# Copyright (c) 2016-2021 Li-Pro.Net, Stephan Linz
#
# ACTIVE: <<image::inherit::central-image>>
#     &&  <<image::feature::tools-profile>>
#

SUMMMARY = "Central Profiling tools"
DESCRIPTION = "The profiling set of packages required for a Central system"
LICENSE = "MIT"
PR = "r0"

inherit packagegroup

RDEPENDS_${PN} = " \
"

RRECOMMENDS_${PN} = " \
"
